#include "hc/display/Framebuffer.h"

namespace hc {

namespace {
// Classic 5x7 font, ASCII 0x20..0x7E, columns LSB = top row.
const uint8_t kFont[][5] = {
    {0x00, 0x00, 0x00, 0x00, 0x00}, {0x00, 0x00, 0x5F, 0x00, 0x00}, {0x00, 0x07, 0x00, 0x07, 0x00},
    {0x14, 0x7F, 0x14, 0x7F, 0x14}, {0x24, 0x2A, 0x7F, 0x2A, 0x12}, {0x23, 0x13, 0x08, 0x64, 0x62},
    {0x36, 0x49, 0x55, 0x22, 0x50}, {0x00, 0x05, 0x03, 0x00, 0x00}, {0x00, 0x1C, 0x22, 0x41, 0x00},
    {0x00, 0x41, 0x22, 0x1C, 0x00}, {0x08, 0x2A, 0x1C, 0x2A, 0x08}, {0x08, 0x08, 0x3E, 0x08, 0x08},
    {0x00, 0x50, 0x30, 0x00, 0x00}, {0x08, 0x08, 0x08, 0x08, 0x08}, {0x00, 0x60, 0x60, 0x00, 0x00},
    {0x20, 0x10, 0x08, 0x04, 0x02}, {0x3E, 0x51, 0x49, 0x45, 0x3E}, {0x00, 0x42, 0x7F, 0x40, 0x00},
    {0x42, 0x61, 0x51, 0x49, 0x46}, {0x21, 0x41, 0x45, 0x4B, 0x31}, {0x18, 0x14, 0x12, 0x7F, 0x10},
    {0x27, 0x45, 0x45, 0x45, 0x39}, {0x3C, 0x4A, 0x49, 0x49, 0x30}, {0x01, 0x71, 0x09, 0x05, 0x03},
    {0x36, 0x49, 0x49, 0x49, 0x36}, {0x06, 0x49, 0x49, 0x29, 0x1E}, {0x00, 0x36, 0x36, 0x00, 0x00},
    {0x00, 0x56, 0x36, 0x00, 0x00}, {0x00, 0x08, 0x14, 0x22, 0x41}, {0x14, 0x14, 0x14, 0x14, 0x14},
    {0x41, 0x22, 0x14, 0x08, 0x00}, {0x02, 0x01, 0x51, 0x09, 0x06}, {0x32, 0x49, 0x79, 0x41, 0x3E},
    {0x7E, 0x11, 0x11, 0x11, 0x7E}, {0x7F, 0x49, 0x49, 0x49, 0x36}, {0x3E, 0x41, 0x41, 0x41, 0x22},
    {0x7F, 0x41, 0x41, 0x22, 0x1C}, {0x7F, 0x49, 0x49, 0x49, 0x41}, {0x7F, 0x09, 0x09, 0x01, 0x01},
    {0x3E, 0x41, 0x41, 0x51, 0x32}, {0x7F, 0x08, 0x08, 0x08, 0x7F}, {0x00, 0x41, 0x7F, 0x41, 0x00},
    {0x20, 0x40, 0x41, 0x3F, 0x01}, {0x7F, 0x08, 0x14, 0x22, 0x41}, {0x7F, 0x40, 0x40, 0x40, 0x40},
    {0x7F, 0x02, 0x04, 0x02, 0x7F}, {0x7F, 0x04, 0x08, 0x10, 0x7F}, {0x3E, 0x41, 0x41, 0x41, 0x3E},
    {0x7F, 0x09, 0x09, 0x09, 0x06}, {0x3E, 0x41, 0x51, 0x21, 0x5E}, {0x7F, 0x09, 0x19, 0x29, 0x46},
    {0x46, 0x49, 0x49, 0x49, 0x31}, {0x01, 0x01, 0x7F, 0x01, 0x01}, {0x3F, 0x40, 0x40, 0x40, 0x3F},
    {0x1F, 0x20, 0x40, 0x20, 0x1F}, {0x7F, 0x20, 0x18, 0x20, 0x7F}, {0x63, 0x14, 0x08, 0x14, 0x63},
    {0x03, 0x04, 0x78, 0x04, 0x03}, {0x61, 0x51, 0x49, 0x45, 0x43}, {0x00, 0x00, 0x7F, 0x41, 0x41},
    {0x02, 0x04, 0x08, 0x10, 0x20}, {0x41, 0x41, 0x7F, 0x00, 0x00}, {0x04, 0x02, 0x01, 0x02, 0x04},
    {0x40, 0x40, 0x40, 0x40, 0x40}, {0x00, 0x01, 0x02, 0x04, 0x00}, {0x20, 0x54, 0x54, 0x54, 0x78},
    {0x7F, 0x48, 0x44, 0x44, 0x38}, {0x38, 0x44, 0x44, 0x44, 0x20}, {0x38, 0x44, 0x44, 0x48, 0x7F},
    {0x38, 0x54, 0x54, 0x54, 0x18}, {0x08, 0x7E, 0x09, 0x01, 0x02}, {0x08, 0x14, 0x54, 0x54, 0x3C},
    {0x7F, 0x08, 0x04, 0x04, 0x78}, {0x00, 0x44, 0x7D, 0x40, 0x00}, {0x20, 0x40, 0x44, 0x3D, 0x00},
    {0x00, 0x7F, 0x10, 0x28, 0x44}, {0x00, 0x41, 0x7F, 0x40, 0x00}, {0x7C, 0x04, 0x18, 0x04, 0x78},
    {0x7C, 0x08, 0x04, 0x04, 0x78}, {0x38, 0x44, 0x44, 0x44, 0x38}, {0x7C, 0x14, 0x14, 0x14, 0x08},
    {0x08, 0x14, 0x14, 0x18, 0x7C}, {0x7C, 0x08, 0x04, 0x04, 0x08}, {0x48, 0x54, 0x54, 0x54, 0x20},
    {0x04, 0x3F, 0x44, 0x40, 0x20}, {0x3C, 0x40, 0x40, 0x20, 0x7C}, {0x1C, 0x20, 0x40, 0x20, 0x1C},
    {0x3C, 0x40, 0x30, 0x40, 0x3C}, {0x44, 0x28, 0x10, 0x28, 0x44}, {0x0C, 0x50, 0x50, 0x50, 0x3C},
    {0x44, 0x64, 0x54, 0x4C, 0x44}, {0x00, 0x08, 0x36, 0x41, 0x00}, {0x00, 0x00, 0x7F, 0x00, 0x00},
    {0x00, 0x41, 0x36, 0x08, 0x00}, {0x08, 0x04, 0x08, 0x10, 0x08},
    // extra glyphs (index 95..): ä ö ü Ä Ö Ü ß ° block flame
    {0x20, 0x55, 0x54, 0x55, 0x78}, {0x38, 0x45, 0x44, 0x45, 0x38}, {0x3C, 0x41, 0x40, 0x21, 0x7C},
    {0x79, 0x14, 0x12, 0x14, 0x79}, {0x39, 0x44, 0x44, 0x44, 0x39}, {0x3D, 0x40, 0x40, 0x40, 0x3D},
    {0x7E, 0x01, 0x49, 0x4E, 0x30}, {0x00, 0x06, 0x09, 0x09, 0x06}, {0x7F, 0x7F, 0x7F, 0x7F, 0x7F},
    {0x30, 0x4C, 0x73, 0x4C, 0x30},
};
constexpr uint8_t kGlyphCount = sizeof(kFont) / sizeof(kFont[0]);
constexpr uint8_t kQuestion = '?' - 0x20;
}  // namespace

const uint8_t* glyphData(uint8_t g) { return kFont[g < kGlyphCount ? g : kQuestion]; }

int nextGlyph(const char* s, uint8_t& g) {
  unsigned char c = static_cast<unsigned char>(s[0]);
  if (c >= 0x20 && c < 0x7F) {
    g = static_cast<uint8_t>(c - 0x20);
    return 1;
  }
  if (c == 0xC3 && s[1]) {
    switch (static_cast<unsigned char>(s[1])) {
      case 0xA4: g = 95; return 2;   // ä
      case 0xB6: g = 96; return 2;   // ö
      case 0xBC: g = 97; return 2;   // ü
      case 0x84: g = 98; return 2;   // Ä
      case 0x96: g = 99; return 2;   // Ö
      case 0x9C: g = 100; return 2;  // Ü
      case 0x9F: g = 101; return 2;  // ß
      default: g = kQuestion; return 2;
    }
  }
  if (c == 0xC2 && static_cast<unsigned char>(s[1]) == 0xB0) {
    g = 102;  // °
    return 2;
  }
  if (c == 0x01) { g = 103; return 1; }  // full block (internal)
  if (c == 0x02) { g = 104; return 1; }  // flame (internal: heating)
  // skip other multi-byte sequences
  int n = 1;
  if ((c & 0xE0) == 0xC0) n = 2;
  else if ((c & 0xF0) == 0xE0) n = 3;
  else if ((c & 0xF8) == 0xF0) n = 4;
  for (int i = 1; i < n; ++i)
    if (!s[i]) return i;
  g = kQuestion;
  return n;
}

void Framebuffer::setPixel(int x, int y, bool on) {
  if (x < 0 || x >= W || y < 0 || y >= H) return;
  uint8_t& b = buf_[(y / 8) * W + x];
  uint8_t m = static_cast<uint8_t>(1u << (y & 7));
  if (on) b |= m;
  else b &= static_cast<uint8_t>(~m);
}

bool Framebuffer::pixel(int x, int y) const {
  if (x < 0 || x >= W || y < 0 || y >= H) return false;
  return buf_[(y / 8) * W + x] & (1u << (y & 7));
}

void Framebuffer::hline(int x, int y, int w, bool on) {
  for (int i = 0; i < w; ++i) setPixel(x + i, y, on);
}
void Framebuffer::vline(int x, int y, int h, bool on) {
  for (int i = 0; i < h; ++i) setPixel(x, y + i, on);
}
void Framebuffer::rect(int x, int y, int w, int h, bool on) {
  hline(x, y, w, on);
  hline(x, y + h - 1, w, on);
  vline(x, y, h, on);
  vline(x + w - 1, y, h, on);
}
void Framebuffer::fillRect(int x, int y, int w, int h, bool on) {
  for (int j = 0; j < h; ++j) hline(x, y + j, w, on);
}
void Framebuffer::invertRect(int x, int y, int w, int h) {
  for (int j = 0; j < h; ++j)
    for (int i = 0; i < w; ++i) setPixel(x + i, y + j, !pixel(x + i, y + j));
}

int Framebuffer::text(int x, int y, const std::string& s, int scale, bool on) {
  const char* p = s.c_str();
  while (*p) {
    uint8_t g;
    p += nextGlyph(p, g);
    const uint8_t* col = glyphData(g);
    for (int c = 0; c < 5; ++c)
      for (int r = 0; r < 7; ++r)
        if (col[c] & (1u << r))
          for (int sy = 0; sy < scale; ++sy)
            for (int sx = 0; sx < scale; ++sx) setPixel(x + c * scale + sx, y + r * scale + sy, on);
    x += 6 * scale;
  }
  return x;
}

int Framebuffer::textWidth(const std::string& s, int scale) {
  int n = 0;
  const char* p = s.c_str();
  while (*p) {
    uint8_t g;
    p += nextGlyph(p, g);
    ++n;
  }
  return n * 6 * scale;
}

int Framebuffer::textFit(int x, int y, const std::string& s, int maxWidth, int scale) {
  if (textWidth(s, scale) <= maxWidth) return text(x, y, s, scale);
  int maxChars = maxWidth / (6 * scale);
  if (maxChars <= 1) return x;
  std::string out;
  const char* p = s.c_str();
  int n = 0;
  while (*p && n < maxChars - 1) {
    uint8_t g;
    int len = nextGlyph(p, g);
    out.append(p, static_cast<size_t>(len));
    p += len;
    ++n;
  }
  out += '.';
  return text(x, y, out, scale);
}

int Framebuffer::textRight(int xRight, int y, const std::string& s, int scale) {
  int w = textWidth(s, scale);
  text(xRight - w + 1, y, s, scale);
  return xRight - w + 1;
}

void Framebuffer::bar(int x, int y, int w, int h, float f) {
  rect(x, y, w, h);
  if (f < 0) f = 0;
  if (f > 1) f = 1;
  fillRect(x + 1, y + 1, static_cast<int>((w - 2) * f + 0.5f), h - 2);
}

void Framebuffer::rotate180() {
  for (int i = 0; i < kBytes / 2; ++i) {
    uint8_t a = buf_[i], b = buf_[kBytes - 1 - i];
    // reverse bit order inside each byte
    auto rev = [](uint8_t v) {
      v = static_cast<uint8_t>((v & 0xF0) >> 4 | (v & 0x0F) << 4);
      v = static_cast<uint8_t>((v & 0xCC) >> 2 | (v & 0x33) << 2);
      v = static_cast<uint8_t>((v & 0xAA) >> 1 | (v & 0x55) << 1);
      return v;
    };
    buf_[i] = rev(b);
    buf_[kBytes - 1 - i] = rev(a);
  }
}

uint32_t Framebuffer::checksum() const {
  uint32_t h = 2166136261u;
  for (uint8_t b : buf_) h = (h ^ b) * 16777619u;
  return h;
}

}  // namespace hc
